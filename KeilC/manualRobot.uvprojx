# Keil uVision project manualRobot.uvprojx, settings and files
target manualRobot (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: manualRobot
  c flags: Optim=3 v6Lang=1 v6LangP=3 wLevel=3
  c define: STM32F40XX, USE_STDPERIPH_DRIVER
  c include: ..\..\..\LIB\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\LIB\STM32F4xx_StdPeriph_Driver\inc;..\..\Robot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group LIB
    ../../../LIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_tim.c
    ../../../LIB/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    ../../../LIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../../../LIB/CMSIS/Include/: core_cm4.h
  group USER
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c
    ./: lcd.o
software components: CMSIS:CORE 5.6.0
